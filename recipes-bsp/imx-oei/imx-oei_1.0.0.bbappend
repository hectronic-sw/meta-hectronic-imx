FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}-1.0.0:"

SRC_URI:append:h6095 = " file://0001-Add-hectronic-ddr-training-data.patch"

