ATF_BOOT_UART_BASE:h6080 = "0x30880000"
