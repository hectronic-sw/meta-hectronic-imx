FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}-2025q4:"

SRC_URI:append:h6095 = " file://0001-Add-h6095-board.patch"

